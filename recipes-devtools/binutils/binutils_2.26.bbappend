FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI_append = "file://1001-fix-werror-formatting.patch \
"
