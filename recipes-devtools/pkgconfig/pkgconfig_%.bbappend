FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI_append = "file://1001-explicit-python2.patch \
                  file://1002-no-Werror-format.patch \
"
